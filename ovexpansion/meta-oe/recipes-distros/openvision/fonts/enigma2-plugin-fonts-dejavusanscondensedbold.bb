# Avoid font extension
FONTNAME = "DejaVuSansCondensed-Bold"

require dejavu-fonts.inc
