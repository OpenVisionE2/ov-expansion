LIC_FILES_CHKSUM:openvision = "file://LICENSE;md5=b234ee4d69f5fce4486a80fdaf4a4263"

RDEPENDS:${PN}:remove:openvision = "oe-alliance-branding"
RDEPENDS:${PN}:append:openvision = " enigma2-data-iso-639-3"
