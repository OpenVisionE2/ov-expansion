SRC_URI:openvision = "git://github.com/OpenViX/servicehisilicon.git;protocol=https;branch=sigc3"
