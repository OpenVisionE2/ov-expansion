DEPENDS:remove:openvision = "enigma2-plugin-extensions-openwebif"
