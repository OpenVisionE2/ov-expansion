RDEPENDS:${PN}:remove:openvision = "oe-alliance-branding"
